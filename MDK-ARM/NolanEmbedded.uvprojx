# Keil uVision project NolanEmbedded.uvprojx, settings and files
target NolanEmbedded (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NolanEmbedded +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middleware/FreeRTOS/Inc;../Middleware/FreeRTOS/Port;../Bsp/RTT/Inc;../Bsp/Beep/Inc;../Bsp/Uart/Inc;../Bsp/Algorithm/Inc;../Bsp/Dwt/Inc;../Bsp/Led/Inc;../Bsp/Daemon/Inc;../Application/commucation/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Inc/: FreeRTOSConfig.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h
    ../Src/: freertos_start.c main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group FreeRTOS/Src
    ../Middleware/FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Port
    ../Middleware/FreeRTOS/Port/: heap_4.c port.c
  group Bsp/Src/RTT
    ../Bsp/RTT/Src/: rtt.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Bsp/Src/Beep
    ../Bsp/Beep/Src/: beep.c
  group Bsp/Src/Uart
    ../Bsp/Uart/Src/: uart.c
  group BSP/Src/Algorithm
    ../Bsp/Algorithm/Src/: crc8.c crc16.c
  group Bsp/Src/Dwt
    ../Bsp/Dwt/Src/: dwt.c
  group Bsp/Src/Led
    ../Bsp/Led/Src/: led.c
  group Bsp/Src/Daemon
    ../Bsp/Daemon/Src/: daemon.c
  group Application/Commucation
    ../Application/commucation/Src/: commucation.c
software components: CMSIS:CORE 4.3.0
